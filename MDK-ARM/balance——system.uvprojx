# Keil uVision project balance——system.uvprojx, settings and files
target balance——system (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: balance_system +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../User/ZDT;../User/Althgrom;../User/App;../User/Bsp;../User/Task
  memory RVCT4: ROM 0x8000000 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c dma.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_crc.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group ZDT
    ../User/ZDT/: Emm_V5.c Emm_V5.h
  group Algorithm
    ../User/Althgrom/: pid.c pid.h dwt_time.c dwt_time.h Test.c Test.h
  group BSP
    ../User/Bsp/: OLED.c OLED.h OLEDFont.h BSP_CRC.c BSP_CRC.h
  group APP
    ../User/App/: Vision.c Vision.h BallBeam.c BallBeam.h vofa.c vofa.h APP_SENSOR.c APP_SENSOR.h motor.c motor.h tracking.c tracking.h
  group Task
    ../User/Task/: Task_Types.h Task_Hmi.c Task_Hmi.h Task_Manager.c Task_Manager.h Task2_CarLap.c Task2_CarLap.h Task3_BallMove.c Task3_BallMove.h Task4_CarToB.c Task4_CarToB.h Task5_CarLapBalance.c Task5_CarLapBalance.h Task6_ArbitraryPosition.c Task6_ArbitraryPosition.h
software components: CMSIS:CORE 4.3.0
